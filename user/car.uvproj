# Keil uVision project car.uvproj, settings and files
target car (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: car +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\core;..\stm32f10x_fwlib\inc;..\SYSTEM\delay;..\hardware\key;..\SYSTEM\sys;..\SYSTEM\usart;..\hardware\led;..\hardware\pwm;..\hardware\direction;..\hardware\speed;..\hardware\pid;..\hardware\24CXX;..\hardware\NRF24L01;..\hardware\SPI;..\hardware\LCD;..\hardware\key
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group core
    ../core/: core_cm3.c startup_stm32f10x_hd.s
  group user
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group system
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group fwlib
    ../stm32f10x_fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hardware
    ../hardware/key/: key.c
    ../hardware/led/: led.c
    ../hardware/pwm/: pwm.c
    ../hardware/direction/: direction.c
    ../hardware/speed/: speed.c
    ../hardware/pid/: pid.c
    ../hardware/NRF24L01/: 24l01.c
    ../hardware/SPI/: spi.c
    ../hardware/LCD/: ILI93xx.c
